# Keil uVision project BurnCob.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: BurnCob +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\main;.\eeprom;.\oled;.\uart;.\74hc595;.\cd4052;.\isr;.\Key
  group main
    ./main/: main.c
  group eeprom
    ./eeprom/: 24c02.c
  group oled
    ./oled/: oled.c
  group uart
    ./uart/: Uart.c
  group 74hc595
    ./74hc595/: _595.c
  group cd4052
    ./cd4052/: cd4052.c
  group isr
    ./isr/: isr.c
  group key
    ./Key/: Key.c
